options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: hrpt_noaa_decoder
    output_language: python
    run_options: run
    title: HRPT NOAA Decoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.002e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.08'
    comment: Q was removed by PLL, we fake it here
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/marc/Downloads/NOAA_19_1698Mhz_6MSPS_Final_short.i8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int((samp_rate/(600*1109))/2.0)
    max_iter: '4000'
    scale: 1.0/((samp_rate/(600*1109))/2.0)
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: decoder
  id: noaa_hrpt_decoder
  parameters:
    output: 'False'
    verbose: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.01'
    gain_omega: 0.01**2/4.0
    mu: '0.5'
    omega: (samp_rate/(600*1109))/2.0
    omega_relative_limit: '100e-6'
    type: float
  states: {}
- name: noaa_hrpt_deframer_0
  id: noaa_hrpt_deframer
  parameters: {}
  states: {}
- name: pll
  id: noaa_hrpt_pll_cf
  parameters:
    alpha: '0.01'
    beta: 0.01**2/4.0
    max_offset: 3*3.14159*100e3/samp_rate
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    grid: 'True'
    label1: '30'
    legend: 'False'
    marker1: '1'
    name: Output Constellation
    size: '1000'
    type: complex
    update_time: '0.02'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.03'
    ymax: '0'
    ymin: '-36'
  states: {}

connections:
- [analog_agc_xx_0, '0', pll, '0']
- [analog_noise_source_x_0, '0', blocks_float_to_complex_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', noaa_hrpt_deframer_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [noaa_hrpt_deframer_0, '0', decoder, '0']
- [pll, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
